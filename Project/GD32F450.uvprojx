# Keil uVision project GD32F450.uvprojx, settings and files
target GD32F450 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F450ZG GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x030000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x0100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: GD32F450 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\Firmware\GD32F4xx_standard_peripheral\Include;..\Firmware\CMSIS;..\Firmware\CMSIS\GD\GD32F4xx\Include;..\User;..\Hardware\led;..\Hardware\usart;..\Hardware\key;..\Hardware\timer;..\Hardware\pwm;..\Hardware\dma;..\Hardware\buzzer;..\Hardware\eye;..\Hardware\adc;..\Hardware\bluetooth;..\Hardware\motor;..\Hardware\lcd;..\Lcdware;..\Hardware\pca9685;..\Hardware\ps2
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/: systick.c main.c gd32f4xx_it.c sys.c
  group CMSIS
    ../Firmware/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
    ../Firmware/CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f450_470.s
  group Hardware
    ../Hardware/led/: bsp_led.c
    ../Hardware/usart/: bsp_usart.c
    ../Hardware/key/: bsp_key.c
    ../Hardware/pwm/: bsp_pwm.c
    ../Hardware/dma/: bsp_dma.c
    ../Hardware/timer/: bsp_timer.c
    ../Hardware/buzzer/: bsp_buzzer.c
    ../Hardware/eye/: bsp_eye.c
    ../Hardware/motor/: bsp_motor.c
    ../Hardware/adc/: bsp_adc.c
    ../Hardware/bluetooth/: bsp_bluetooth.c
    ../Hardware/lcd/: bsp_lcd.c
    ../Hardware/pca9685/: bsp_pca9685.c
    ../Hardware/ps2/: bsp_ps2.c
  group Firmware
    ../Firmware/GD32F4xx_standard_peripheral/Source/: gd32f4xx_gpio.c gd32f4xx_rcu.c gd32f4xx_usart.c gd32f4xx_misc.c gd32f4xx_syscfg.c gd32f4xx_exti.c gd32f4xx_timer.c gd32f4xx_dma.c gd32f4xx_adc.c gd32f4xx_wwdgt.c
  group Doc
    ../Doc/: readme.txt
